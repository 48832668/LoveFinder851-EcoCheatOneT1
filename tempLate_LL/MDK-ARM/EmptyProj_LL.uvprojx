# Keil uVision project EmptyProj_LL.uvprojx, settings and files
target EmptyProj_LL (6240000::V6.24::ARMCLANG)
  device: PY32F003x8 Puya
  pack: Puya.PY32F0xx_DFP.1.2.8
  cpu: IRAM(0x20000000,0x20002000) IROM(0x08000000,0x08010000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: EmptyProj_LL +hex
  c flags: Optim=2 OneElfS=1 uC99=1 uGnu=1 v6Lang=5 v6LangP=9 wLevel=3
  c define: PY32F003x8,USE_FULL_LL_DRIVER
  c misc: -Wno-register
  c include: ../Core/INC;../Drivers/CMSIS/Include;../Drivers/PY32F003_HAL_Driver/Inc;../Drivers/CMSIS/Device/PY32F003/Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group Application/MDK-ARM
    ./: startup_py32f003xx.s
  group Application/User/Core
    ../Core/SRC/: main.cpp main.c gpio.c dma.c crc.c tim.c usart.c spi.c i2c.c rcc.c py32f003_it.c
  group Drivers/CMSIS
    ../Core/SRC/: system_py32f003.c
  group Drivers/PY32F003_HAL_Driver
    ../Drivers/PY32F003_HAL_Driver/Src/: py32f0xx_ll_utils.c py32f0xx_ll_rcc.c py32f0xx_ll_dma.c py32f0xx_ll_pwr.c py32f0xx_ll_gpio.c py32f0xx_ll_exti.c py32f0xx_ll_i2c.c py32f0xx_ll_spi.c py32f0xx_ll_usart.c py32f0xx_ll_tim.c py32f0xx_ll_crc.c
