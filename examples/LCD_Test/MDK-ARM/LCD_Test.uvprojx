# Keil uVision project LCD_Test.uvprojx, settings and files
target LCD_Test (6240000::V6.24::ARMCLANG)
  device: PY32F003x8 Puya
  pack: Puya.PY32F0xx_DFP.1.2.8
  cpu: IRAM(0x20000000,0x00002000) IROM(0x08000000,0x00010000) IROM2(0x1FFF0E80,0x00000010) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: LCD_Test +hex
  c flags: Optim=2 OneElfS=1 uC99=1 uGnu=1 v6Lang=5 v6LangP=8 wLevel=3
  c define: PY32F003x8,USE_HAL_DRIVER
  c include: ../Core/INC;../User/ST7735;../Drivers/CMSIS/Include;../Drivers/PY32F003_HAL_Driver/Inc;../Drivers/CMSIS/Device/PY32F003/Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT5: ROM 0x1fff0e80 size 0x10
  memory RVCT9: RAM 0x20000000 size 0x2000
  group Drivers/PY32F003_HAL_Driver
    ../Drivers/PY32F003_HAL_Driver/Src/: py32f0xx_hal_rcc.c py32f0xx_hal_rcc_ex.c py32f0xx_hal_pwr.c py32f0xx_hal_exti.c py32f0xx_hal_gpio.c py32f0xx_hal_i2c.c py32f0xx_hal_spi.c py32f0xx_hal_usart.c py32f0xx_hal_uart.c py32f0xx_hal_tim.c py32f0xx_hal_tim_ex.c py32f0xx_hal_crc.c py32f0xx_hal.c py32f0xx_hal_dma.c py32f0xx_hal_cortex.c
  group Application/User/Core
    ../Core/SRC/: rcc.c gpio.c py32f003_it.c i2c.c spi.c usart.c tim.c main.c py32f003_hal_msp.c crc.c
  group User/ST7735
    ../User/ST7735/: st7735.c fonts.c
  group Application/MDK
    ./: startup_py32f003.s
  group Drivers/CMSIS
    ../Core/SRC/: system_py32f003.c
