# Keil uVision project PD_PDO_List_Det.uvprojx, settings and files
target PD_PDO_List_Det (6240000::V6.24::ARMCLANG)
  device: PY32F003x8 Puya
  pack: Puya.PY32F0xx_DFP.1.2.8
  cpu: IRAM(0x20000000,0x00002000) IROM(0x08000000,0x00010000) IROM2(0x1FFF0E80,0x00000010) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: PD_PDO_List_Det +hex
  c flags: Optim=2 OneElfS=1 uC99=1 uGnu=1 v6Lang=5 v6LangP=9 v6Lto=1 wLevel=3
  c define: PY32F003x8,USE_FULL_LL_DRIVER,ST7735_USE_DMA=1
  c misc: -Wno-register
  c include: ../Core/INC;../LoveFinderLib/FontLib;../../../../LoveFinderLibForPY32_LL/FontLib;../../../../LoveFinderLibForPY32_LL/ST7735;../../../../LoveFinderLibForPY32_LL/SPI;../../../../LoveFinderLibForPY32_LL/FUSB302;../Drivers/CMSIS/Include;../Drivers/PY32F003_LL_Driver/Inc;../Drivers/CMSIS/Device/PY32F003/Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT5: ROM 0x1fff0e80 size 0x10
  memory RVCT9: RAM 0x20000000 size 0x2000
  group Drivers/PY32F003_LL_Driver
    ../Drivers/PY32F003_LL_Driver/Src/: py32f0xx_ll_utils.c py32f0xx_ll_rcc.c py32f0xx_ll_gpio.c py32f0xx_ll_exti.c py32f0xx_ll_pwr.c py32f0xx_ll_usart.c py32f0xx_ll_dma.c py32f0xx_ll_spi.c py32f0xx_ll_i2c.c py32f0xx_ll_tim.c py32f0xx_ll_crc.c py32f0xx_ll_adc.c py32f0xx_ll_comp.c py32f0xx_ll_lptim.c py32f0xx_ll_rtc.c py32f0xx_ll_led.c
  group Application/User/Core
    ../Core/SRC/: main.cpp gpio.cpp rcc.cpp usart.cpp i2c.cpp tim.cpp crc.cpp spi.cpp py32f003_it.cpp
  group LoveFinderLibForPY32_LL/ST7735
    ../../../../LoveFinderLibForPY32_LL/ST7735/: st7735.cpp icons.c
  group LoveFinderLibForPY32_LL/FontLib
    ../../../../LoveFinderLibForPY32_LL/FontLib/: font_data.cpp
  group LoveFinderLibForPY32_LL/FUSB302
    ../../../../LoveFinderLibForPY32_LL/FUSB302/: FUSB302.cpp
  group Application/MDK-ARM
    ./: startup_py32f003xx.s
  group Drivers/CMSIS
    ../Core/SRC/: system_py32f003.c
